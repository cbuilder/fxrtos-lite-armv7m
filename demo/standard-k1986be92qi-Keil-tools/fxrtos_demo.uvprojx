# Keil uVision project fxrtos_demo.uvprojx, settings and files
target fxrtos_demo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: fxrtos_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: fxrtos.lib FXRTOS.h MDR32F9Qx_config.h startup_MDR32F9Qx.s main.c
  group device_support
    ./: MDR32F9Qx_lib.h MDR32F9Qx_rst_clk.c MDR32F9Qx_rst_clk.h MDR32Fx.h core_cm3.h system_MDR32F9Qx.c system_MDR32F9Qx.h
software components: CMSIS:CORE 5.3.0
